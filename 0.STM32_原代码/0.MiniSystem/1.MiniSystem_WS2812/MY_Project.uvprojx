# Keil uVision project MY_Project.uvprojx, settings and files
target MY_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MY_Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\3.Libraries\CMSIS;.\3.Libraries\CMSIS\core;.\3.Libraries\CMSIS\startup;.\3.Libraries\STM32F10x_StdPeriph_Driver\inc;.\2.User;.\2.User\delay;.\2.User\sys;.\2.User\led;.\2.User\usart_debug;.\2.User\font;.\2.User\144lcd_st7735s;.\2.User\spi2;.\2.User\key;.\2.User\ws2812b
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./2.User/: main.c stm32f10x_conf.h
    ./2.User/sys/: sys.c
    ./2.User/delay/: delay.c
    ./2.User/led/: led.c
    ./2.User/usart_debug/: usart_debug.c
    ./2.User/font/: fonts.c
    ./2.User/144lcd_st7735s/: 144lcd_st7735s.c
    ./2.User/spi2/: spi2.c
    ./2.User/key/: key.c
    ./2.User/ws2812b/: ws2812b.c
  group CMSIS
    ./3.Libraries/CMSIS/startup/: startup_stm32f10x_md.s
    ./3.Libraries/CMSIS/: system_stm32f10x.c
    ./3.Libraries/CMSIS/core/: core_cm3.c
  group FWLIB
    ./3.Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_tim.c
  group DOC
    ./4.Doc/: readme.txt
