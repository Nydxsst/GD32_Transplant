# Keil uVision project MY_Project.uvprojx, settings and files
target MY_Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MY_Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32E103V_EVAL
  c include: .\3.Libraries\CMSIS;.\3.Libraries\CMSIS\core;.\3.Libraries\CMSIS\startup;.\3.Libraries\GD32E10x_standard_peripheral\Include;.\2.User;.\2.User\delay;.\2.User\sys;.\2.User\led;.\2.User\usart_debug;.\2.User\144lcd_st7735s;.\2.User\font;.\2.User\spi1;.\2.User\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./2.User/: main.c gd32e10x_libopt.h gd32e10x_it.c
    ./2.User/delay/: delay.c
    ./2.User/sys/: sys.c
    ./2.User/led/: led.c
    ./2.User/usart_debug/: usart_debug.c
    ./2.User/144lcd_st7735s/: 144lcd_st7735s.c
    ./2.User/font/: fonts.c
    ./2.User/spi1/: spi1.c
    ./2.User/adc/: adc.c
  group CMSIS
    ./3.Libraries/CMSIS/startup/: startup_gd32e10x.s
    ./3.Libraries/CMSIS/: system_gd32e10x.c
  group FWLIB
    ./3.Libraries/GD32E10x_standard_peripheral/Source/: gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_usart.c gd32e10x_rcu.c gd32e10x_spi.c gd32e10x_adc.c
  group DOC
    ./4.Doc/: readme.txt
